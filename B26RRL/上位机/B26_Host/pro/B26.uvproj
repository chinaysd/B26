# Keil uVision project B26.uvproj, settings and files
target B26 (MCS-51)
  device: SC93F8332 SC93Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0x3FF) CLOCK(24000000)
  output: B26 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC93F833X_C.H S_TouchKeyCFG.C SC93F8XXX_HighSensitive_Lib_T1_V0.0.2.LIB
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_uart.c bsp_key.c key_port.c bsp_pwm.c bsp_motro.c bsp_lock.c bsp_wdt.c
  group TimeOut
    ../TimeOut/: TimeOut.c
