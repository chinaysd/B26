# Keil uVision project B26_Slave.uvproj, settings and files
target B26_Slave (MCS-51)
  device: SC92F7322 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(24000000)
  output: B26_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bsp;..\lib;..\TimeOut;..\user
  group startup
    ./: STARTUP.A51
  group user
    ../user/: main.c system.c
  group lib
    ../lib/: SC92F732X_C.H
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c bsp_uart.c bsp_push.c bsp_table.c bsp_key.c
  group TimeOut
    ../TimeOut/: TimeOut.c
